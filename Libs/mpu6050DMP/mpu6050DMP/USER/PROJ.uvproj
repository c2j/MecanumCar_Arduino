# Keil uVision project PROJ.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: PROJ +hex
  c flags: Optim=1
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\CODE;..\USMART;..\CODE\DMP
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group USER
    ./: PROJ.c
  group CODE
    ../CODE/: led.c key.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group DMP
    ../CODE/DMP/: IOI2C.c inv_mpu.c inv_mpu_dmp_motion_driver.c dmpctl.c
